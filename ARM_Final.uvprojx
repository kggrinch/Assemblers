# Keil uVision project ARM_Final.uvprojx, settings and files
target Target_1 (6230000::V6.23::ARMCLANG)
  device: TM4C129XNCZAD Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ARM_Final
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Source Group 1
    ./: heap_template.s stdlib_template.s svc_template.s timer_template.s driver.c driver_cpg.c driver_keil.c heap_template.c
software components: CMSIS:CORE 6.1.0, Device:Startup 1.0.0
